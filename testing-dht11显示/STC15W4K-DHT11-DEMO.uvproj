# Keil uVision project STC15W4K-DHT11-DEMO.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: STC15W4K-DHT11-DEMO +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\SRC
  group Source Group 1
    ./SRC/: delay.c dht11.c
    ./user/: main.c
    ./: oled.c
